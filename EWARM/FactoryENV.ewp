# IAR project FactoryENV.ewp, settings and files
configuration FactoryENV (ARM, debug)
  General.OGChipSelectEditMenu: STM32F401RE ST STM32F401RE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 6
  ICCARM.CCDefines: APP_SPI_IFC; USE_HAL_DRIVER; STM32F401xE
  ICCARM.CCIncludePath2: ../Inc; C:/Users/marek novotny/STM32Cube/Repository/STM32Cube_FW_F4_V1.28.1/Drivers/STM32F4xx_HAL_Driver/Inc; C:/Users/marek novotny/STM32Cube/Repository/STM32Cube_FW_F4_V1.28.1/Drivers/STM32F4xx_HAL_Driver/Inc/Legacy; C:/Users/marek novotny/STM32Cube/Repository/STM32Cube_FW_F4_V1.28.1/Drivers/CMSIS/Device/ST/STM32F4xx/Include; C:/Users/marek novotny/STM32Cube/Repository/STM32Cube_FW_F4_V1.28.1/Drivers/CMSIS/Include; C:/Users/marek novotny/STM32Cube/Repository//Packs/STMicroelectronics/X-CUBE-IPS/3.0.0/Drivers/BSP/Components/ips8200hq; C:/Users/marek novotny/STM32Cube/Repository//Packs/STMicroelectronics/X-CUBE-IPS/3.0.0/Drivers/BSP/OUT16A1; ../Drivers/BSP/STM32F4xx_Nucleo; ../Drivers/STM32F4xx_HAL_Driver/Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32F4xx/Include; ../Drivers/CMSIS/Include; ../Drivers/BSP/Components/ips8200hq; ../Drivers/BSP/OUT16A1
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: FactoryENV.hex
  ILINK.IlinkOutputFile: FactoryENV.out
  ILINK.IlinkIcfFile: stm32f401xe_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f401xe.s
  group Application/User
    ../Src/: main.c app_ips_custom.c app_ips_switch.c stm32f4xx_nucleo_bus.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/BSP/Components
    C:/Users/marek novotny/STM32Cube/Repository//Packs/STMicroelectronics/X-CUBE-IPS/3.0.0/Drivers/BSP/Components/ips8200hq/: ips8200hq.c
    ../Drivers/BSP/Components/ips8200hq/: ips8200hq.c
  group Drivers/BSP/OUT16A1
    C:/Users/marek novotny/STM32Cube/Repository//Packs/STMicroelectronics/X-CUBE-IPS/3.0.0/Drivers/BSP/OUT16A1/: out16a1.c out16a1_bus.c
    ../Drivers/BSP/OUT16A1/: out16a1.c out16a1_bus.c
  group Drivers/BSP/STM32F4xx_Nucleo
    ../Drivers/BSP/STM32F4xx_Nucleo/: stm32f4xx_nucleo.c
  group Drivers/STM32F4xx_HAL_Driver
    C:/Users/marek novotny/STM32Cube/Repository/STM32Cube_FW_F4_V1.28.1/Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_spi.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_spi.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
